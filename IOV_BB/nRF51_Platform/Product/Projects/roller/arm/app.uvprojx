# Keil uVision project app.uvprojx, settings and files
target Release (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: fromelf --bin -o build\app.bin build\app.axf
  AfterMake: ..\..\..\Tools\install.bat
  c flags: Optim=4 uC99=1
  c include: ..\..\..\sdk\include
  library: MicroLIB
  memory RVCT4: ROM 0x34000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\sdk\lib\juma_sdk.sct
  group Application
    ../: app.c HDC1080.c
  group Library
    ../../../sdk/lib/: juma_sdk.lib
  group segger_rtt
    ../segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 3.40.0
