# Keil uVision project juma_sdk.uvprojx, settings and files
target Library (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: juma_sdk (library)
  AfterMake: .\install.bat
  c flags: Optim=4 uC99=1
  c include: ..\Include;..\Source
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source
    ../Source/: juma_sdk_lib.c
